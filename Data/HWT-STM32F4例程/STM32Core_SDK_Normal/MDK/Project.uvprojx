# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Source\APP;..\Source\STM32F4xxLib\inc;..\Source\STM32F4xxLib\M4;..\Source\Drive;..\Source\wit_c_sdk
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../Source/APP/: Main.c
    ../Source/wit_c_sdk/: REG.h wit_c_sdk.c
  group DRIVER
    ../Source/Drive/: UART2.c UART1.c delay.c
  group FWLib
    ../Source/STM32F4xxLib/M4/: system_stm32f4xx.c stm32f4xx_it.c stm32f4xx.h
    ../Source/STM32F4xxLib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_pwr.c
    ../Source/STM32F4xxLib/startup/: startup_stm32f40_41xxx.s
software components: CMSIS:CORE 5.0.1
